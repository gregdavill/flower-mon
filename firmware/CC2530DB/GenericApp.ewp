# IAR project GenericApp.ewp, settings and files
configuration CHDTECH_DEV (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: HAL_BOARD_CHDTECH_DEV
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.PreInclude: ..\src\preinclude.h
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\src; ..\vendor\BME280_driver; ..\vendor\zstack-lib; ..\vendor\Z-Stack_3.0.2\Projects\zstack\HomeAutomation\Source; ..\vendor\Z-Stack_3.0.2\Projects\zstack\ZMain\TI2530DB; ..\vendor\Z-Stack_3.0.2\Components\hal\include; ..\vendor\Z-Stack_3.0.2\Components\hal\target\CC2530EB; ..\vendor\Z-Stack_3.0.2\Components\mac\include; ..\vendor\Z-Stack_3.0.2\Components\mac\high_level; ..\vendor\Z-Stack_3.0.2\Components\mac\low_level\srf04; ..\vendor\Z-Stack_3.0.2\Components\mac\low_level\srf04\single_chip; ..\vendor\Z-Stack_3.0.2\Components\mt; ..\vendor\Z-Stack_3.0.2\Components\osal\include; ..\vendor\Z-Stack_3.0.2\Components\services\saddr; ..\vendor\Z-Stack_3.0.2\Components\services\sdata; ..\vendor\Z-Stack_3.0.2\Components\stack\af; ..\vendor\Z-Stack_3.0.2\Components\stack\bdb; ..\vendor\Z-Stack_3.0.2\Components\stack\gp; ..\vendor\Z-Stack_3.0.2\Components\stack\nwk; ..\vendor\Z-Stack_3.0.2\Components\stack\sapi; ..\vendor\Z-Stack_3.0.2\Components\stack\sec; ..\vendor\Z-Stack_3.0.2\Components\stack\sys; ..\vendor\Z-Stack_3.0.2\Components\stack\zcl; ..\vendor\Z-Stack_3.0.2\Components\stack\zdo; ..\vendor\Z-Stack_3.0.2\Components\zmac; ..\vendor\Z-Stack_3.0.2\Components\zmac\f8w
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  ICC8051.IccLang: 0
  prebuild: Python.exe "..\ver.py"
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration DIYRuZ_Flower (8051)
  as the first configuration, except:
  ICC8051.CCDefines: HAL_BOARD_FLOWER
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\BME280_driver; ..\zstack-lib; ..\..\Source; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\bdb; ..\..\..\..\..\Components\stack\gp; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
  ICC8051.CCOptStrategy: 1
  group App
    ../BME280_driver/: bme280.c bme280.h bme280_defs.h
    ../zstack-lib/: hal_key.c hal_key.h
    ../Source/: OSAL_App.c preinclude.h stdint.h version.c version.h zcl_app.c zcl_app.h zcl_app_data.c
  group BDB
    ../../../../../Components/stack/bdb/: bdb.c bdb.h bdb_FindingAndBinding.c bdb_interface.h bdb_Reporting.c bdb_Reporting.h bdb_tlCommissioning.c bdb_tlCommissioning.h bdb_touchlink.c bdb_touchlink.h bdb_touchlink_initiator.c bdb_touchlink_initiator.h
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../Source/hal/: ds18b20.h
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    ../Source/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../Components/hal/target/CC2530EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    ../../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_APP_CONFIG.c MT_APP_CONFIG.h MT_DEBUG.c MT_DEBUG.h MT_GP.c MT_GP.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../../../Components/stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group Profile
    ../../../../../Components/stack/af/: AF.c AF.h
    ../../../../../Components/stack/zcl/: zcl.c zcl.h zcl_general.c zcl_general.h zcl_lighting.c zcl_lighting.h
    ../../Source/: zcl_ha.c zcl_ha.h
  group Security
    ../../../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../../Tools/CC2530DB/: f8w2530.xcl f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg f8wZCL.cfg
    ../zstack-lib/: f8wConfig.cfg
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
  group zstack-lib
    ../zstack-lib/: battery.h bettery.c commissioning.c commissioning.h Debug.c Debug.h ds18b20.c ds18b20.h factory_reset.c factory_reset.h hal_i2c.c hal_i2c.h utils.c utils.h
